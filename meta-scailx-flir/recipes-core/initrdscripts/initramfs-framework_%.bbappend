FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
# temporarily overide the camera power-on sequence to prevent i2c from being blocked